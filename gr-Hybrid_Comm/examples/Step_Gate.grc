options:
  parameters:
    generate_options: qt_gui
    id: Step_Gate
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ramp
  id: variable
  parameters:
    value: range(-100,100)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Hybrid_Comm_Step_Gate_0
  id: Hybrid_Comm_Step_Gate
  parameters:
    hopPoints: (-1, +1)
    levels: (2, 3, 4)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[4*x/len(Ramp) for x in Ramp]'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[0,]*len(Ramp)'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Hybrid_Comm_Step_Gate_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_vector_source_x_0, '0', Hybrid_Comm_Step_Gate_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0_0_0, '0', Hybrid_Comm_Step_Gate_0, '1']
- [blocks_vector_source_x_0_0_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
