options:
  parameters:
    generate_options: qt_gui
    id: Remove_Header
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Counter
  id: variable
  parameters:
    value: (1, 1, 0, 0, 0, 0, 0, 0)
  states: {}
- name: Data
  id: variable
  parameters:
    value: range(0, 50)
  states: {}
- name: Label_bit
  id: variable
  parameters:
    value: (0,1,0,0,1,0,1,0,)
  states: {}
- name: Label_str
  id: variable
  parameters:
    value: '"R"'
  states: {}
- name: LengthOffset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Preamble
  id: variable
  parameters:
    value: (2, 2, 2, 2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Hybrid_Comm_Remove_Header_0
  id: Hybrid_Comm_Remove_Header
  parameters:
    label: Label_str
    packetSampLen: len(Data)*4
    preamble: Preamble
    samplesPerBit: '1'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/len(Data)
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[len(Preamble), len(Label_bit), len(Counter), len(Data) + LengthOffset]'
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: '[len(Preamble)+len(Label_bit)+len(Counter)+len(Data) + LengthOffset, ]*4'
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Preamble
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Label_bit
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Counter
  states: {}
- name: blocks_vector_source_x_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Data
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    color2: cyan
    color3: red
    ctrlpanel: 'True'
    label1: Data
    label2: Sync
    label3: Counter
    marker1: '0'
    marker2: '1'
    marker3: '7'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Hybrid_Comm_Remove_Header_0, '0', blocks_char_to_float_0, '0']
- [Hybrid_Comm_Remove_Header_0, '1', blocks_char_to_float_0_0, '0']
- [Hybrid_Comm_Remove_Header_0, '2', blocks_short_to_float_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_stream_mux_0, '0', blocks_stream_mux_1, '0']
- [blocks_stream_mux_0, '0', blocks_stream_mux_1, '1']
- [blocks_stream_mux_0, '0', blocks_stream_mux_1, '2']
- [blocks_stream_mux_0, '0', blocks_stream_mux_1, '3']
- [blocks_stream_mux_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', Hybrid_Comm_Remove_Header_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_mux_0, '2']
- [blocks_vector_source_x_0_0_0_0, '0', blocks_stream_mux_0, '3']

metadata:
  file_format: 1
