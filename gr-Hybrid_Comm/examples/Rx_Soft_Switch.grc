options:
  parameters:
    generate_options: qt_gui
    id: Rx_Soft_Switch
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Data_1
  id: variable
  parameters:
    value: '[1,]*20'
  states: {}
- name: Data_2
  id: variable
  parameters:
    value: '[2,]*20'
  states: {}
- name: Th
  id: variable_qtgui_range
  parameters:
    label: Threshold
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: range(-50, 50)
  states: {}
- name: Hybrid_Comm_Rx_Soft_Switch_0
  id: Hybrid_Comm_Rx_Soft_Switch
  parameters:
    packetSize: len(Data_1)
    sampsPerPacket_1: (1, 2, 4)
    sampsPerPacket_2: (4, 2, 1)
    thresh: (-10, 10)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Data_1
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[Th,]'
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Data_2
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: link 1
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Hybrid_Comm_Rx_Soft_Switch_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_0, '0', Hybrid_Comm_Rx_Soft_Switch_0, '0']
- [blocks_vector_source_x_0_0, '0', Hybrid_Comm_Rx_Soft_Switch_0, '2']
- [blocks_vector_source_x_0_1, '0', Hybrid_Comm_Rx_Soft_Switch_0, '1']

metadata:
  file_format: 1
