options:
  parameters:
    generate_options: qt_gui
    id: Link_Tester
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ctrl
  id: variable
  parameters:
    value: '[1,]*np.random.randint(0, 100) +[255,]*np.random.randint(0, 100)'
  states: {}
- name: Data_1
  id: variable
  parameters:
    value: '[1,]*np.random.randint(0, 100)'
  states: {}
- name: Data_2
  id: variable
  parameters:
    value: Data_1 + [0,]*np.random.randint(0, 100)
  states: {}
- name: SpB
  id: variable
  parameters:
    value: '[np.random.randint(0, 10),]*np.random.randint(0, 100) + [np.random.randint(0, 10),]*np.random.randint(0, 100)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Hybrid_Comm_Link_Tester_0
  id: Hybrid_Comm_Link_Tester
  parameters:
    packetSize: '10'
    samp_rate: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Data_1
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Data_2
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Ctrl
  states: {}
- name: blocks_vector_source_x_0_1_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: SpB
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0
    label1: link 1
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: BER
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0, 1
    label1: link 1
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Link Availability (%)
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0, 2
    label1: link 1
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Link Throughput (kb/s)
  states: {}

connections:
- [Hybrid_Comm_Link_Tester_0, '0', qtgui_time_sink_x_0, '0']
- [Hybrid_Comm_Link_Tester_0, '1', qtgui_time_sink_x_0_0, '0']
- [Hybrid_Comm_Link_Tester_0, '2', qtgui_time_sink_x_0_0_0, '0']
- [blocks_throttle_0, '0', Hybrid_Comm_Link_Tester_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_1, '0', Hybrid_Comm_Link_Tester_0, '1']
- [blocks_vector_source_x_0_1_0, '0', Hybrid_Comm_Link_Tester_0, '2']
- [blocks_vector_source_x_0_1_0_0, '0', Hybrid_Comm_Link_Tester_0, '3']

metadata:
  file_format: 1
