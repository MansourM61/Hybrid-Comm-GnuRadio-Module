options:
  parameters:
    generate_options: qt_gui
    id: Signal_Quality_Metre
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Hybrid_Comm_Signal_Quality_Metre_0
  id: Hybrid_Comm_Signal_Quality_Metre
  parameters:
    edgeFindingRange: '10'
    measType: Q-factor
    sampsPerSymb: '10'
    winSize: '1000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.15811388300841897'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    color2: blue
    color3: red
    label1: Signal
    label2: Merit
    label3: Mean
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    style1: '2'
    type: float
    ymax: '+2'
    ymin: '-2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: '[1,]*10'
    type: fff
  states: {}

connections:
- [Hybrid_Comm_Signal_Quality_Metre_0, '0', qtgui_time_sink_x_0, '1']
- [Hybrid_Comm_Signal_Quality_Metre_0, '1', qtgui_time_sink_x_0, '2']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', Hybrid_Comm_Signal_Quality_Metre_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
