options:
  parameters:
    generate_options: qt_gui
    id: Tx_Hard_Switch
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Data
  id: variable
  parameters:
    value: range(0, 100)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: range(-int(len(Data)/2), int(len(Data)/2))
  states: {}
- name: Hybrid_Comm_Tx_Hard_Switch_0
  id: Hybrid_Comm_Tx_Hard_Switch
  parameters:
    sampsPerBit: (1, 2)
    thresh: '0'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Data
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: thresh
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: link 1
    label2: link 2
    marker1: '0'
    marker2: '1'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Hybrid_Comm_Tx_Hard_Switch_0, '0', blocks_char_to_float_0, '0']
- [Hybrid_Comm_Tx_Hard_Switch_0, '1', blocks_char_to_float_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', Hybrid_Comm_Tx_Hard_Switch_0, '0']
- [blocks_throttle_0_0, '0', Hybrid_Comm_Tx_Hard_Switch_0, '1']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
