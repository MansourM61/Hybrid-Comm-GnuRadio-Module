options:
  parameters:
    generate_options: qt_gui
    id: Add_Header
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Hybrid_Comm_Add_Header_0
  id: Hybrid_Comm_Add_Header
  parameters:
    label: L1
    packetSampLen: '100'
    preamble: (2, 2, 2, 2, 3, 3, 3, 3,)
    samplesPerBit: '5'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (2,)*1000 + (5,)*1000
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (6,)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: data
    label2: SpB
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Hybrid_Comm_Add_Header_0, '0', blocks_char_to_float_0, '0']
- [Hybrid_Comm_Add_Header_0, '1', blocks_char_to_float_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', Hybrid_Comm_Add_Header_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_1, '0', Hybrid_Comm_Add_Header_0, '1']

metadata:
  file_format: 1
