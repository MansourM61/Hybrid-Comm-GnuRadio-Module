options:
  parameters:
    generate_options: qt_gui
    id: Slicer
    max_nouts: '100'
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Hybrid_Comm_Slicer_0
  id: Hybrid_Comm_Slicer
  parameters:
    avgWinSize: '20'
    packetSize: '1000'
    thresh: '0.5'
  states: {}
- name: Hybrid_Comm_Source_BV_0
  id: Hybrid_Comm_Source_BV
  parameters:
    packetSize: '1000'
    signalType: Random
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (5,)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    marker2: '1'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style2: '2'
    type: float
  states: {}

connections:
- [Hybrid_Comm_Slicer_0, '0', blocks_char_to_float_0, '0']
- [Hybrid_Comm_Source_BV_0, '0', blocks_char_to_float_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', Hybrid_Comm_Slicer_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0_0, '0', Hybrid_Comm_Source_BV_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
