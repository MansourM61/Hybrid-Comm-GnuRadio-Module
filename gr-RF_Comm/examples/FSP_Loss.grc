options:
  parameters:
    generate_options: qt_gui
    id: RF_Blocks
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LinkLen
  id: variable_qtgui_range
  parameters:
    label: Link length (m)
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10000'
    value: '100'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    orient: Qt.Horizontal
    start: '0.1'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: RF_Comm_FSP_Loss_0
  id: RF_Comm_FSP_Loss
  parameters:
    freq: freq*1e6
    linkLen: LinkLen
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [RF_Comm_FSP_Loss_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', RF_Comm_FSP_Loss_0, '0']

metadata:
  file_format: 1
