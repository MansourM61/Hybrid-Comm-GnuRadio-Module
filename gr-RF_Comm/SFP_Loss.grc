options:
  parameters:
    generate_options: qt_gui
    id: FSP_Loss
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Len
  id: variable_qtgui_range
  parameters:
    label: Link length (m)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: RF_Comm_FSP_Loss_0
  id: RF_Comm_FSP_Loss
  parameters:
    freq: 10.0e9
    linkLen: Len
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Before
    label2: After
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [RF_Comm_FSP_Loss_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', RF_Comm_FSP_Loss_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
