options:
  parameters:
    generate_options: qt_gui
    id: Turbulence
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Cn2
  id: variable_qtgui_range
  parameters:
    label: Cn2 (m^-2/3)
    orient: Qt.Horizontal
    start: math.log(1e-20)
    step: '0.01'
    stop: math.log(1e-10)
    value: math.log(1e-15)
  states: {}
- name: jitter
  id: variable_qtgui_range
  parameters:
    label: Jitter (mm)
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1000'
    value: '200'
  states: {}
- name: linklen
  id: variable_qtgui_range
  parameters:
    label: Link length (m)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '100'
  states: {}
- name: rx_dia
  id: variable_qtgui_range
  parameters:
    label: Receiver aperture diameter (mm)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: wavelen
  id: variable_qtgui_range
  parameters:
    label: Wavelength (nm)
    orient: Qt.Horizontal
    start: '400'
    step: '0.1'
    stop: '1600'
    value: '850'
  states: {}
- name: FSO_Comm_Turbulence_0
  id: FSO_Comm_Turbulence
  parameters:
    Cn2: math.exp(Cn2)
    diaRx: rx_dia
    linkLen: linklen
    sampRate: samp_rate
    tempCorr: '10.0'
    wavelength: wavelen
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Before
    label2: After
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [FSO_Comm_Turbulence_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', FSO_Comm_Turbulence_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
