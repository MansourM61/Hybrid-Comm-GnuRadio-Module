options:
  parameters:
    generate_options: qt_gui
    id: Pointing_Errors
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: jitter
  id: variable_qtgui_range
  parameters:
    label: Jitter (mm)
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1000'
    value: '200'
  states: {}
- name: linklen
  id: variable_qtgui_range
  parameters:
    label: Link length (m)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '100'
  states: {}
- name: rx_dia
  id: variable_qtgui_range
  parameters:
    label: Receiver aperture diameter (mm)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    label: Transmitter full angle divergence (mDeg)
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1000'
    value: '0.1'
  states: {}
- name: tx_dia
  id: variable_qtgui_range
  parameters:
    label: Transmitter aperture diameter (mm)
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '100'
    value: '3'
  states: {}
- name: FSO_Comm_Pointing_Errors_0
  id: FSO_Comm_Pointing_Errors
  parameters:
    diaRx: rx_dia
    diaTx: tx_dia
    jitter: jitter
    linkLen: linklen
    sampRate: samp_rate
    tempCorr: '10.0'
    thetaTx: theta
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Before
    label2: After
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [FSO_Comm_Pointing_Errors_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', FSO_Comm_Pointing_Errors_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
